Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2025-01-20T10:21:30
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcDistributionControlElement: NBS_BenderUK_DgtlMtrngEqpmnt_LINETRAXXPEM353PowerQualityMeasuring:PEM353, NBS_BenderUK_DgtlMtrngEqpmnt_LINETRAXXPEM353PowerQualityMeasuring:PEM353:313513
In: Level 0
Type - Classification: Pr_80_51_51_22 (Uniclass2015); Material: NBS_BenderUK_Grey (5), NBS_BenderUK_DisplayScreen (3), NBS_BenderUK_Yellow, NBS_BenderUK_Green (2)
Type - IFC - IfcExportAs: IfcFlowInstrumentType; IfcExportType: COMBINED
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_80_51_51_22:Digital metering equipment; Color: n/a; Finish: n/a; Material: n/a; Shape: Square; Size: n/a; WarrantyDescription: Two year; CodePerformance: n/a; Constituents: n/a; Description: A digital universal measuring device for electricity supply networks.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: marketing@bender-uk.com; ModelNumber: n/a; ModelReference: LINETRAXX® PEM353 Power Quality Measuring; Name: DigitalMeteringEquipment_LINETRAXXPEM353PowerQualityMeasuring_PEM353_BenderUK; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_BenderUK_DigitalMeteringEquipment_LINETRAXXPEM353PowerQualityMeasuring_PEM353; ManufacturerName: Bender UK; ManufacturerURL: www.bender-uk.com; ProductInformation: https://source.thenbs.com/product/-/7d67bd71-9080-4d17-a8fa-9892d99a11ae/9085cb80-18d5-4a51-9f3f-85c2b299f610; Uniclass2015Code: Pr_80_51_51_22; Uniclass2015Title: Digital metering equipment; Uniclass2015Version: Products v1.36; Version: 2
Type - NBS_Data - Standards: To DIN EN 62053-22, DIN EN 61557-12 and DIN IEC 61554; CountryOfProductManufacture: Germany; Material: n/a; Recyclability: Can be returned to manufacturer for recycling under WEEE regulations; Display: LCD graphic display; RatedVoltage: TN and TT system (earthed): a.c. 230/400–400/690 V, CAT III 600 V IT system (unearthed): a.c. 400–480 V, CAT III 300 V/ a.c. 500–690 V, CAT II 1000 V; PhaseArrangement: Single phase, two-wire,Three phase, three-wire,Three phase, four-wire; CurrentMeasuringRange: Via external CTs 1 A or 5 A; RatedFrequency: 45–65 Hz; MeteringFunctions: Phase (V).Line-to-line voltages (V).Phase currents (A).Neutral current (A).Residual current (A).Frequency (Hz).Power per phase conductor (kVA).Displacement factor cos φ.Power factor (λ).Active and reactive energy import (kWh, kvarh).Voltage phase angle (°).Current phase angle (°).Voltage unbalance (%).Current unbalance (%).Harmonic distortion (THD, TOHD, TEHD) for U and I.k-factor for I.Crest factor for I.Total demand distortion (TDD) for I; IngressProtectionMinimum: IP20 (installation); IP54 (front, with rubber seal); Outputs: 2 x relay; Communications: RS-485 (Modbus RTU, BACnet MS/TP, DNP); Connections: Screw-type terminals, plug-in connector; InputCurrent: Current inputs (I1, I2, I3): 5 A/ 1 A
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
NBS_Data - Mounting: Front panel

# IfcDistributionPort, Port_313513
Description: Flow; FlowDirection: SOURCEANDSINK
